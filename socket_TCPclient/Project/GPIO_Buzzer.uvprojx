# Keil uVision project GPIO_Buzzer.uvprojx, settings and files
target GPIO_Buzzer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1788 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO_Buzzer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress=186
  c include: ..\..\BoardSupport;..\..\Core\CM3\CoreSupport;..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x;..\..\Drivers\include;..\User;.\FreeRTOS\include;.\FreeRTOS;.\FreeRTOS\portable\RVDS\ARM_CM3;..\..\Drivers\include;..\Lwip\include;..\User\arch;..\Lwip\include\lwip;..\User\arch
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  group Startup
    ../../Core/CM3/DeviceSupport/NXP/LPC177x_8x/startup/arm/: startup_LPC177x_8x.s
  group CMSIS
    ../../Core/CM3/CoreSupport/: core_cm3.c
    ../../Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
  group Drivers
    ../../Drivers/source/: lpc177x_8x_systick.c lpc177x_8x_gpio.c lpc177x_8x_clkpwr.c lpc177x_8x_uart.c lpc177x_8x_pinsel.c lpc177x_8x_emac.c
  group User
    ../User/: GPIO_Buzzer.c UART2.c lwip.c client.c
    ../User/arch/: phylan.c EMAC.c
  group FreeRTOS/src
    ./FreeRTOS/: croutine.c event_groups.c FreeRTOSConfig.h list.c stream_buffer.c tasks.c timers.c queue.c
  group FreeRTOS/port
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group LwIP/api
    ../Lwip/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/core
    ../Lwip/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Lwip/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP/netif
    ../Lwip/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c
  group LwIP/arch
    ../User/arch/: sys_arch.c ethernetif.c
software components: CMSIS:CORE 5.1.1
